# Keil uVision project Foc example.uvprojx, settings and files
target Foc example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Foc example +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1
  c include: ..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32g430_std_periph_driver\inc;..\User;..\BSP;..\DSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../User/: n32g430_it.c main.c PI.c Svm.c LPF.c Foc.c Table.c Timer.c DataCalc.c Observer.c CurrSample.c LoopControl.c StateMachine.c AxisTransform.c HeadFile.h Parameter.h
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g430.c
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g430.s
  group DOC
    ../Doc/: ReadMe.txt
  group FWLIB
    ../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_beeper.c n32g430_can.c n32g430_comp.c n32g430_crc.c n32g430_dbg.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_i2c.c n32g430_iwdg.c n32g430_lptim.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c n32g430_wwdg.c
  group DSP
    ../DSP/: arm_atan2_f32.c arm_common_tables.c arm_cos_f32.c arm_sin_cos_f32.c arm_sin_f32.c
  group BSP
    ../BSP/: bsp_adc.c bsp_config.c bsp_led.c bsp_tim.c i2c_eeprom.c
