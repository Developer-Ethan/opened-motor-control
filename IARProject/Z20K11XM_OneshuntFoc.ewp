# IAR project Z20K11XM_OneshuntFoc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20K116M ZhiXin Z20K116M
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEV_Z20K116M
  ICCARM.CCIncludePath2: ..\SDK\Platform; ..\SDK\Platform\Core; ..\SDK\Platform\Devices; ..\SDK\Platform\Devices\Z20K116M\Inc; ..\SDK\StdDriver\Inc; ..\Solution\Z20A8300A\inc; ..\Solution\Z20A8300A\confg; ..\Solution\Z20K116M\Foc\MC_AxisTransform; ..\Solution\Z20K116M\Foc\MC_CurrSample; ..\Solution\Z20K116M\Foc\MC_DataCalc; ..\Solution\Z20K116M\Foc\MC_HeadFile; ..\Solution\Z20K116M\Foc\MC_Init; ..\Solution\Z20K116M\Foc\MC_LoopControl; ..\Solution\Z20K116M\Foc\MC_Lpf; ..\Solution\Z20K116M\Foc\MC_Observer; ..\Solution\Z20K116M\Foc\MC_Parameter; ..\Solution\Z20K116M\Foc\MC_Pi; ..\Solution\Z20K116M\Foc\MC_StateMachine; ..\Solution\Z20K116M\Foc\MC_Svm; ..\Solution\Z20K116M\Foc\MC_Table; ..\Solution\Z20K116M\Foc\MC_Timer; ..\Solution\Z20K116M\App; ..\Solution\Z20K116M\MidLayer; ..\Solution\Z20K116M\Bsp\timer; ..\Solution\Z20K116M\Bsp\adc; ..\Solution\Z20K116M\Bsp\clock; ..\Solution\Z20K116M\Bsp\dma; ..\Solution\Z20K116M\Bsp\hwdiv; ..\Solution\Z20K116M\Bsp\nvic; ..\Solution\Z20K116M\Bsp\stim; ..\Solution\Z20K116M\Bsp\tmu; ..\Solution\Z20K116M\Bsp\zxmath; ..\Solution\Z20K116M\Bsp\hwcfg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Z20K11XM_OneshuntFoc.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: E:\Project\Yuntu\Indepentent research\Based on Z20K116M-Git\SDK\Platform\Devices\Z20K116M\MakeRule\IAR\Z20K116M_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Platform/Core
    ../SDK/Platform/Core/: arm_compat.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group Platform/Devices/Inc
    ../SDK/Platform/Devices/Z20K116M/Inc/: Z20K116M.h
  group Platform/Devices/Startup
    ../SDK/Platform/Devices/Z20K116M/Startup/IAR/: Z20K116M_startup.s
  group Solution/Z20A8300A/confg
    ../Solution/Z20A8300A/confg/: Z20A8300A_Hal.c Z20A8300A_Init.c
  group Solution/Z20A8300A/inc
    ../Solution/Z20A8300A/inc/: Z20A8300A_Config.h Z20A8300A_Ctrl.h Z20A8300A_Diag.h Z20A8300A_If.h Z20A8300A_Reg.h Z20A8300A_Spi.h Z20A8300A_Type.h
  group Solution/Z20A8300A/src
    ../Solution/Z20A8300A/src/: Z20A8300A_Config.c Z20A8300A_Ctrl.c Z20A8300A_Diag.c Z20A8300A_Spi.c
  group Solution/Z20K116M/App
    ../Solution/Z20K116M/App/: AppHeadFile.h AppParameter.h main.c
  group Solution/Z20K116M/Bsp
    ../Solution/Z20K116M/Bsp/hwcfg/: hal_cfg.h
  group Solution/Z20K116M/Bsp/adc
    ../Solution/Z20K116M/Bsp/adc/: adc.c adc.h
  group Solution/Z20K116M/Bsp/clock
    ../Solution/Z20K116M/Bsp/clock/: clock.c clock.h
  group Solution/Z20K116M/Bsp/dma
    ../Solution/Z20K116M/Bsp/dma/: dma.c dma.h
  group Solution/Z20K116M/Bsp/hwdiv
    ../Solution/Z20K116M/Bsp/hwdiv/: hwdiv.c hwdiv.h
  group Solution/Z20K116M/Bsp/nvic
    ../Solution/Z20K116M/Bsp/nvic/: nvic.c nvic.h
  group Solution/Z20K116M/Bsp/stim
    ../Solution/Z20K116M/Bsp/stim/: stim.c stim.h
  group Solution/Z20K116M/Bsp/timer
    ../Solution/Z20K116M/Bsp/timer/: timer.c timer.h
  group Solution/Z20K116M/Bsp/tmu
    ../Solution/Z20K116M/Bsp/tmu/: tmu.c tmu.h
  group Solution/Z20K116M/Bsp/zxmath
    ../Solution/Z20K116M/Bsp/zxmath/: zxmathfp.c zxmathfp.h
  group Solution/Z20K116M/Foc
    ../Solution/Z20K116M/Foc/MC_HeadFile/: HeadFile.h
    ../Solution/Z20K116M/Foc/MC_Parameter/: Parameter.h
  group Solution/Z20K116M/Foc/MC_AxisTransform
    ../Solution/Z20K116M/Foc/MC_AxisTransform/: AxisTransform.c AxisTransform.h
  group Solution/Z20K116M/Foc/MC_CurrSample
    ../Solution/Z20K116M/Foc/MC_CurrSample/: CurrSample.c CurrSample.h
  group Solution/Z20K116M/Foc/MC_DataCalc
    ../Solution/Z20K116M/Foc/MC_DataCalc/: DataCalc.c DataCalc.h
  group Solution/Z20K116M/Foc/MC_Init
    ../Solution/Z20K116M/Foc/MC_Init/: FocInit.c FocInit.h
  group Solution/Z20K116M/Foc/MC_LoopControl
    ../Solution/Z20K116M/Foc/MC_LoopControl/: SpdLoop.c SpdLoop.h
  group Solution/Z20K116M/Foc/MC_Lpf
    ../Solution/Z20K116M/Foc/MC_Lpf/: LPF.c LPF.h
  group Solution/Z20K116M/Foc/MC_Observer
    ../Solution/Z20K116M/Foc/MC_Observer/: Observer.c Observer.h
  group Solution/Z20K116M/Foc/MC_Pi
    ../Solution/Z20K116M/Foc/MC_Pi/: PI.c PI.h
  group Solution/Z20K116M/Foc/MC_StateMachine
    ../Solution/Z20K116M/Foc/MC_StateMachine/: StateMachine.c StateMachine.h
  group Solution/Z20K116M/Foc/MC_Svm
    ../Solution/Z20K116M/Foc/MC_Svm/: Svm.c Svm.h
  group Solution/Z20K116M/Foc/MC_Table
    ../Solution/Z20K116M/Foc/MC_Table/: Table.c Table.h
  group Solution/Z20K116M/Foc/MC_Timer
    ../Solution/Z20K116M/Foc/MC_Timer/: AiTimer.c
  group Solution/Z20K116M/MidLayer
    ../Solution/Z20K116M/MidLayer/: IRQHandler.c Midlayer.h
  group StdDriver/Inc
    ../SDK/StdDriver/Inc/: Z20K11xM_adc.h Z20K11xM_can.h Z20K11xM_clock.h Z20K11xM_cmp.h Z20K11xM_crc.h Z20K11xM_dma.h Z20K11xM_drv.h Z20K11xM_ewdt.h Z20K11xM_flash.h Z20K11xM_gpio.h Z20K11xM_hwdiv.h Z20K11xM_i2c.h Z20K11xM_pmu.h Z20K11xM_regfile.h Z20K11xM_rtc.h Z20K11xM_spi.h Z20K11xM_srmc.h Z20K11xM_stim.h Z20K11xM_sysctrl.h Z20K11xM_tdg.h Z20K11xM_tim.h Z20K11xM_tmu.h Z20K11xM_uart.h Z20K11xM_wdog.h
  group StdDriver/Src
    ../SDK/StdDriver/Src/: Z20K11xM_adc.c Z20K11xM_can.c Z20K11xM_clock.c Z20K11xM_cmp.c Z20K11xM_crc.c Z20K11xM_dma.c Z20K11xM_drv.c Z20K11xM_ewdt.c Z20K11xM_flash.c Z20K11xM_gpio.c Z20K11xM_hwdiv.c Z20K11xM_i2c.c Z20K11xM_pmu.c Z20K11xM_regfile.c Z20K11xM_rtc.c Z20K11xM_spi.c Z20K11xM_srmc.c Z20K11xM_stim.c Z20K11xM_sysctrl.c Z20K11xM_tdg.c Z20K11xM_tim.c Z20K11xM_tmu.c Z20K11xM_uart.c Z20K11xM_wdog.c
